# Keil uVision project demo.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\modbus;..\User\modbus\ascii;..\User\dataprocess;..\User\modbus\functions;..\User\modbus\include;..\User\modbus\rtu;..\User\port;..\User\SCREEN_DRIVE;..\Libraries\STM32_Cryptographic_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: main.c stm32f4xx_it.c pidcontroller.c
    ../User/gpio/: gpio.c
    ../User/delaytime/: delaytime.c
    ../User/usart/: usart.c
    ../User/adc/: adc.c
    ../User/dac/: dac.c
    ../User/dataprocess/: dataprocess.c
    ../User/flash/: deviceinfo.c flash.c
    ../User/max6675/: max6675.c
    ../User/pwm/: pwm.c
    ../User/queue/: queue.c
    ../User/screen/: screen.c
    ../User/status/: status.c
    ../User/tim/: tim.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Modbus
    ../User/modbus/ascii/: mbascii.c mbascii.h
    ../User/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../User/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../User/modbus/tcp/: mbtcp.c mbtcp.h
    ../User/modbus/: mb.c
    ../User/port/: port.h portevent.c portserial.c porttimer.c
  group Screen_Driver
    ../User/SCREEN_DRIVE/: cmd_queue.c cmd_queue.h hmi_driver.c hmi_driver.h hmi_user_uart.c hmi_user_uart.h
  group STM32_Crypto_library
    ../Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M3_CryptoFW_RngHW_2_0_6.lib M3_CryptoHW_2_0_6.lib
software components: CMSIS:DSP 1.4.5
